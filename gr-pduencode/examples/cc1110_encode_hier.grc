options:
  parameters:
    author: ethan
    description: This block encodes a message of type PDU into a CC1110 structured packet of type PDU.
    generate_options: hb
    id: cc1110_encode_hier
    output_language: python
    title: CC1110 Encoder
  states: {}

blocks:
- name: bit_per_sym
  id: parameter
  parameters:
    label: Bits Per Symbol
    type: intx
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pduencode_add_length_0
  id: pduencode_add_length
  parameters:
    crc16_present: 'False'
  states: {}
- name: pduencode_crc16_0
  id: pduencode_crc16
  parameters: {}
  states: {}
- name: pduencode_custom_hex_1
  id: pduencode_custom_hex
  parameters:
    comment: add extra byte so crc16 doesnt get flipped randomly
    head_tail: 'False'
    hex_str: '00'
  states: {}
- name: pduencode_preamble_0
  id: pduencode_preamble
  parameters:
    num_bytes: preamble_bytes
  states: {}
- name: pduencode_syncword_0
  id: pduencode_syncword
  parameters:
    syncword_str: sync_word
  states: {}
- name: preamble_bytes
  id: parameter
  parameters:
    label: Number Of Preamble Bytes
    type: intx
    value: '2'
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples Per Symbol
    type: intx
    value: '5'
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: sync_word
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '11010011100100011101001110010001'
  states: {}

connections:
- [pad_source_0, out, pduencode_add_length_0, in]
- [pduencode_add_length_0, out, pduencode_crc16_0, in]
- [pduencode_crc16_0, out, blocks_message_debug_0, print_pdu]
- [pduencode_crc16_0, out, satellites_pn9_scrambler_0, in]
- [pduencode_custom_hex_1, out, pad_sink_0, in]
- [pduencode_preamble_0, out, pduencode_custom_hex_1, in]
- [pduencode_syncword_0, out, pduencode_preamble_0, in]
- [satellites_pn9_scrambler_0, out, pduencode_syncword_0, in]

metadata:
  file_format: 1
