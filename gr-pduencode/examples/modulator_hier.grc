options:
  parameters:
    author: ethan
    description: This block GFSK modulates a packet of type PDU to be transmitted by the Tx USRP.
    generate_options: hb
    id: modulator_hier
    output_language: python
    title: Modulator
  states: {}

blocks:
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: samp_per_sym
    sensitivity: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_usrp
    taps: ''
    type: ccc
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '5'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '48000'
  states: {}
- name: samp_rate_usrp
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '2000000'
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [rational_resampler_xxx_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
