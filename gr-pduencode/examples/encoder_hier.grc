options:
  parameters:
    author: ethan
    description: This block encodes a message of type PDU into a CC1110 structured packet of type PDU.
    generate_options: hb
    id: encode_hier
    output_language: python
    title: Encoder
  states: {}

blocks:
- name: bits_per_sym
  id: parameter
  parameters:
    label: Bits per symbol
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pduencode_bytes_0
  id: pduencode_bytes
  parameters:
    add: sync_word
  states: {}
- name: pduencode_bytes_0_0
  id: pduencode_bytes
  parameters:
    add: preamble
  states: {}
- name: pduencode_crc16_0
  id: pduencode_crc16
  parameters: {}
  states: {}
- name: pduencode_length_0
  id: pduencode_length
  parameters: {}
  states: {}
- name: pduencode_usrp_pad_0
  id: pduencode_usrp_pad
  parameters:
    bits_per_symbol: bits_per_sym
    samples_per_symbol: samp_per_sym
  states: {}
- name: preamble
  id: parameter
  parameters:
    label: Preamble
    type: str
    value: '"1010101010101010"'
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '5'
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: sync_word
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '"11010011100100011101001110010001"'
  states: {}

connections:
- [pad_source_0, out, pduencode_length_0, in]
- [pduencode_bytes_0, out, pduencode_bytes_0_0, in]
- [pduencode_bytes_0_0, out, pduencode_usrp_pad_0, in]
- [pduencode_crc16_0, out, satellites_pn9_scrambler_0, in]
- [pduencode_length_0, out, pduencode_crc16_0, in]
- [pduencode_usrp_pad_0, out, pad_sink_0, in]
- [satellites_pn9_scrambler_0, out, pduencode_bytes_0, in]

metadata:
  file_format: 1
