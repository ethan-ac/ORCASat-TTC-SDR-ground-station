options:
  parameters:
    author: ethan
    generate_options: hb
    id: openlst_encode_hier
    output_language: python
    title: OpenLST Encoder
  states: {}

blocks:
- name: bit_per_sym
  id: parameter
  parameters:
    label: Bits per symbol
    type: intx
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pduencode_add_length_0
  id: pduencode_add_length
  parameters:
    crc16_present: 'True'
  states: {}
- name: pduencode_byte_flip_0
  id: pduencode_byte_flip
  parameters:
    crc16: 'True'
    hwid: 'False'
    seqnum: 'False'
  states: {}
- name: pduencode_crc16_0
  id: pduencode_crc16
  parameters: {}
  states: {}
- name: pduencode_custom_hex_0
  id: pduencode_custom_hex
  parameters:
    comment: adds system field for openlst style rf packet
    head_tail: 'True'
    hex_str: system
  states: {}
- name: pduencode_custom_hex_1
  id: pduencode_custom_hex
  parameters:
    comment: add extra byte so crc16 doesnt get flipped randomly
    head_tail: 'False'
    hex_str: '00'
  states: {}
- name: pduencode_hwid_mover_0
  id: pduencode_hwid_mover
  parameters: {}
  states: {}
- name: pduencode_preamble_0
  id: pduencode_preamble
  parameters:
    num_bytes: preamble_bytes
  states: {}
- name: pduencode_syncword_0
  id: pduencode_syncword
  parameters:
    syncword_str: sync_word
  states: {}
- name: pduencode_usrp_pad_0
  id: pduencode_usrp_pad
  parameters:
    bits_per_symbol: bit_per_sym
    samples_per_symbol: samp_per_sym
  states: {}
- name: preamble_bytes
  id: parameter
  parameters:
    label: Number of preamble bytes
    type: intx
    value: '2'
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '5'
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: sync_word
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '11010011100100011101001110010001'
  states: {}
- name: system
  id: parameter
  parameters:
    label: System
    type: str
    value: '40'
  states: {}

connections:
- [pad_source_0, out, pduencode_hwid_mover_0, in]
- [pduencode_add_length_0, out, pduencode_crc16_0, in]
- [pduencode_byte_flip_0, out, pduencode_custom_hex_1, in]
- [pduencode_crc16_0, out, pduencode_byte_flip_0, in]
- [pduencode_custom_hex_0, out, pduencode_add_length_0, in]
- [pduencode_custom_hex_1, out, pduencode_usrp_pad_0, in]
- [pduencode_hwid_mover_0, out, pduencode_custom_hex_0, in]
- [pduencode_preamble_0, out, pad_sink_0, in]
- [pduencode_syncword_0, out, pduencode_preamble_0, in]
- [pduencode_usrp_pad_0, out, blocks_message_debug_0, print_pdu]
- [pduencode_usrp_pad_0, out, satellites_pn9_scrambler_0, in]
- [satellites_pn9_scrambler_0, out, pduencode_syncword_0, in]

metadata:
  file_format: 1
