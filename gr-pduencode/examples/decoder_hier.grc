options:
  parameters:
    author: ethan
    description: This block decodes a CC1110 and OpenLST RF structured packets. It also checks the crc16 of packets.
    generate_options: hb
    id: decoder_hier
    output_language: python
    title: Decoder
  states: {}

blocks:
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ok
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: fail
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pduencode_autoswitch_0
  id: pduencode_autoswitch
  parameters: {}
  states: {}
- name: pduencode_byte_flip_0
  id: pduencode_byte_flip
  parameters:
    crc16: 'False'
    hwid: 'True'
    seqnum: 'True'
  states: {}
- name: pduencode_byte_flip_0_0
  id: pduencode_byte_flip
  parameters:
    crc16: 'True'
    hwid: 'False'
    seqnum: 'False'
  states: {}
- name: pduencode_byte_flip_0_0_0
  id: pduencode_byte_flip
  parameters:
    crc16: 'False'
    hwid: 'True'
    seqnum: 'True'
  states: {}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    use_crc16: 'True'
  states: {}
- name: satellites_cc11xx_packet_crop_0_0
  id: satellites_cc11xx_packet_crop
  parameters:
    use_crc16: 'False'
  states: {}
- name: satellites_check_cc11xx_crc_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {}
- name: satellites_check_cc11xx_crc_0_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: sync_word
    threshold: '1'
  states: {}
- name: sync_word
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '11010011100100011101001110010001'
  states: {}

connections:
- [pad_source_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [pduencode_autoswitch_0, CC1110, satellites_cc11xx_packet_crop_0, in]
- [pduencode_autoswitch_0, OpenLST, satellites_cc11xx_packet_crop_0_0, in]
- [pduencode_byte_flip_0, out, pad_sink_0, in]
- [pduencode_byte_flip_0_0, out, satellites_check_cc11xx_crc_0_0, in]
- [pduencode_byte_flip_0_0_0, out, pad_sink_0_0, in]
- [satellites_cc11xx_packet_crop_0, out, satellites_check_cc11xx_crc_0, in]
- [satellites_cc11xx_packet_crop_0_0, out, pduencode_byte_flip_0_0, in]
- [satellites_check_cc11xx_crc_0, fail, pad_sink_0_0, in]
- [satellites_check_cc11xx_crc_0, ok, pad_sink_0, in]
- [satellites_check_cc11xx_crc_0_0, fail, pduencode_byte_flip_0_0_0, in]
- [satellites_check_cc11xx_crc_0_0, ok, pduencode_byte_flip_0, in]
- [satellites_pn9_scrambler_0, out, pduencode_autoswitch_0, in]
- [satellites_sync_to_pdu_packed_0, out, satellites_pn9_scrambler_0, in]

metadata:
  file_format: 1
