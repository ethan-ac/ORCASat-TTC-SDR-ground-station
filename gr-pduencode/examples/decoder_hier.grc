options:
  parameters:
    author: ethan
    description: This block decodes a CC1110 structured packet to be only the length field and data field, it also checks the crc16.
    generate_options: hb
    id: decoder_hier
    output_language: python
    title: Decoder
  states: {}

blocks:
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ok
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: fail
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    use_crc16: 'True'
  states: {}
- name: satellites_check_cc11xx_crc_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: sync_word
    threshold: '1'
  states: {}
- name: sync_word
  id: parameter
  parameters:
    label: Syncword
    value: '"11010011100100011101001110010001"'
  states: {}

connections:
- [pad_source_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [satellites_cc11xx_packet_crop_0, out, satellites_check_cc11xx_crc_0, in]
- [satellites_check_cc11xx_crc_0, fail, pad_sink_0_0, in]
- [satellites_check_cc11xx_crc_0, ok, pad_sink_0, in]
- [satellites_pn9_scrambler_0, out, satellites_cc11xx_packet_crop_0, in]
- [satellites_sync_to_pdu_packed_0, out, satellites_pn9_scrambler_0, in]

metadata:
  file_format: 1
