options:
  parameters:
    author: ethan
    generate_options: qt_gui
    id: gndstation_hiers
    output_language: python
    title: gndstation_hiers
  states: {}

blocks:
- name: bit_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '437025000'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: post_tx
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pre_tx
  id: variable
  parameters:
    comment: |-
      5 <= pre_tx
      starts to lag pre_tx <= 500
      unreliable delay value pre_tx <= 25
    value: '50'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '"1010101010101010"'
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '"11010011100100011101001110010001"'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '5.0'
    samp_rate: samp_rate
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: toggle
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: amp_key_0
  id: amp_key
  parameters:
    post_tx: '50'
    pre_tx: '50'
    samp_rate_usrp: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: toggle
    type: complex
  states: {}
- name: decoder_hier_0
  id: decoder_hier
  parameters:
    sync_word: '"11010011100100011101001110010001"'
  states: {}
- name: demodulator_hier_1
  id: demodulator_hier
  parameters:
    gain_mu: 0.175*3
    samp_rate: '48000'
    samp_rate_usrp: '2000000'
  states: {}
- name: encode_hier_0
  id: encode_hier
  parameters:
    bits_per_sym: '1'
    preamble: '"1010101010101010"'
    samp_per_sym: '5'
    sync_word: '"11010011100100011101001110010001"'
  states: {}
- name: modulator_hier_0
  id: modulator_hier
  parameters:
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
    samp_rate_usrp: samp_rate_usrp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"receive"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '433000000'
    fftsize: '1024'
    name: '"send"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"send"'
    size: '262144'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"receive"'
    size: '262144'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S:%f'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate_usrp
    center_freq0: freq
    dev_addr: '"serial=308F983"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_usrp
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate_usrp
    center_freq0: freq
    comment: '"serial=30875ED"'
    dc_offs_enb0: '""'
    dev_addr: '"serial=308F983"'
    dev_args: '""'
    gain0: rgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_usrp
    sync: none
    type: fc32
  states: {}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    timeout: '100'
  states: {state: disabled}
- name: zpdu_pub_push_test_0
  id: zpdu_pub_push_test
  parameters:
    address: tcp://127.0.0.1:55555
    comment: pub binds to radio_terminal
    connection: 'True'
    socket: '1'
    timeout: '100'
  states: {}
- name: zpdu_sub_pull_test_0
  id: zpdu_sub_pull_test
  parameters:
    address: tcp://127.0.0.1:44444
    comment: pull binds to radio_terminal
    connection: 'True'
    socket: '7'
    timeout: '100'
  states: {}
- name: zpdu_sub_pull_test_0_0
  id: zpdu_sub_pull_test
  parameters:
    address: tcp://127.0.0.1:66666
    comment: sub connects to RX_Radio_terminal
    connection: 'False'
    socket: '2'
    timeout: '100'
  states: {}

connections:
- [amp_key_0, '0', qtgui_freq_sink_x_1, '0']
- [amp_key_0, '0', qtgui_time_sink_x_2, '0']
- [amp_key_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_mute_xx_0, '0']
- [blocks_mute_xx_0, '0', amp_key_0, '0']
- [decoder_hier_0, fail, satellites_print_timestamp_0, in]
- [decoder_hier_0, ok, satellites_print_timestamp_0, in]
- [demodulator_hier_1, '0', decoder_hier_0, '0']
- [encode_hier_0, out, blocks_message_debug_0, print_pdu]
- [encode_hier_0, out, modulator_hier_0, in]
- [modulator_hier_0, '0', blocks_mute_xx_0, '0']
- [satellites_print_timestamp_0, out, blocks_message_debug_0_1, print_pdu]
- [uhd_usrp_source_0, '0', demodulator_hier_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_0, '0']
- [zeromq_sub_msg_source_1, out, blocks_message_debug_0, print_pdu]
- [zeromq_sub_msg_source_1, out, encode_hier_0, in]
- [zeromq_sub_msg_source_1, out, zpdu_pub_push_test_0, in]
- [zpdu_sub_pull_test_0, out, blocks_message_debug_0, print_pdu]
- [zpdu_sub_pull_test_0, out, encode_hier_0, in]
- [zpdu_sub_pull_test_0_0, out, blocks_message_debug_0, print_pdu]
- [zpdu_sub_pull_test_0_0, out, encode_hier_0, in]
- [zpdu_sub_pull_test_0_0, out, zpdu_pub_push_test_0, in]

metadata:
  file_format: 1
