options:
  parameters:
    author: ethan
    generate_options: qt_gui
    id: pduzmq_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: pduzmq_newzmq_0
  id: pduzmq_newzmq
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    comment: Connects flowgraph to zmq script
    timeout: '100'
  states: {}

connections:
- [zeromq_sub_msg_source_1, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
